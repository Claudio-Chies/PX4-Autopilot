## src/modules/para_vario/Kconfig
```kconfig
menuconfig MODULES_PARA_VARIO
	bool "para_vario"
	default n
	---help---
		Enable support for paraglider variometer module
```
